;
; TP06.asm
;
; Created: 19/04/2021
; Author : Hammer Horror - Komatsu's PC.
;


 
;/////////////////    /////	       /////    //////////////////    //////////////////    //////////////////    ////    ////////////////    ///////		  ////	
;/////////////////    /////	 	   /////    //////////////////    //////////////////    //////////////////    ////    ////////////////    //// ///		  ////							
;/////		 /////    /////	 	   /////    /////			      /////						   ////		      ////    /////	     /////    ////  ///	      ////
;/////		 /////    /////		   /////    /////				  /////						   ////		      ////    /////	     /////    ////   ///      ////
;/////		 /////    /////	 	   /////    //////////////////	  //////////////////		   ////			  ////    /////	     /////    ////    ///	  ////
;/////		 /////    /////		   /////    //////////////////	  //////////////////		   ////			  ////    /////	     /////    ////     ///    ////
;/////		 /////    /////	 	   /////    /////					     	   /////		   ////			  ////    /////	     /////    ////      ///	  ////
;/////	///  /////    /////		   /////    /////							   /////		   ////			  ////    /////	     /////    ////	    ///   ////   
;/////	  ////////    /////		   /////    /////							   /////		   ////			  ////    /////	     /////    ////	     ///  ////	
;/////////////////    //////////////////    //////////////////	  //////////////////		   ////			  ////	  ////////////////    ////	      ////////
;/////////////////    //////////////////    //////////////////	  //////////////////		   ////			  ////	  ////////////////    ////		   ///////	

.device atmega328P
.nolist
.list

.ORG 0X000
    rjmp INICIO

INICIO:

	LDI r16, 0b00101011 ; 43
	MOV r5, r16
	LDI r17, 0b00110111 ; 55
	LDI r18, 0x2D ; 45
	MOV r0, r17
	MOV r1, r18
	RCALL DIVIDE
	LSL r5 
	MOV r19, r2 
	MOV r20, r3 
	SUB r5, r19 
LOOP:
	rjmp LOOP
DIVIDE:
	CLR r2 //Limpa r2
	MOV r4,r0 // Copio r0 para r4
DIV_LOOP:
	SUB r4,r1
	BRLO DIV_SAIR
	INC r2 // Incrementa r2	(dividendo)
	RJMP DIV_LOOP
DIV_SAIR:
	ADD r4, r1
	MOV r3, r4
	RET
.EXIT 